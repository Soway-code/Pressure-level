/**@file        ModBus_RTU.c
* @brief        ModBus RTU 通信协议
* @details      RTU 报文处理
* @author       庄明群
* @date         2020-07-20
* @version      V2.0.0
* @copyright    2020-2030,深圳市信为科技发展有限公司
**********************************************************************************
* @par 修改日志:
* <table>
* <tr><th>Date        <th>Version  <th>Author  <th>Maintainer  <th>Description
* <tr><td>2020/07/20  <td>2.0.0    <td>庄明群  <td>杨春林      <td>新添加的程序代码(RTU协议部分)
* </table>
*
**********************************************************************************
*/

#include "ModBus_RTU.h"


#if defined(USING_MODBUS_RTU)
///< CRC_16正规查询表
/** CRC低位字节值表 */
const uint8_t auchCRCLo[256] =
{
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40
};

/** CRC高位字节值表 */
const uint8_t auchCRCHi[256] =
{
    0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06,
    0x07, 0xC7, 0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD,
    0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,
    0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A,
    0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC, 0x14, 0xD4,
    0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
    0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3,
    0xF2, 0x32, 0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4,
    0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,
    0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29,
    0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF, 0x2D, 0xED,
    0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
    0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60,
    0x61, 0xA1, 0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67,
    0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,
    0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68,
    0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA, 0xBE, 0x7E,
    0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
    0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71,
    0x70, 0xB0, 0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92,
    0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,
    0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B,
    0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89, 0x4B, 0x8B,
    0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
    0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42,
    0x43, 0x83, 0x41, 0x81, 0x80, 0x40
};

/**@brief       对输入的消息包进行CRC16校验
* @param[in]    Msg : 消息包缓存;
* @param[in]    MsgLen : 消息包长度;
* @return       函数执行结果
* - CRC16校验码
* @note         消息长度不能为0
*/
uint16_t MDB_Get_CRC16(uint8_t *Msg, uint16_t MsgLen) 
{
    uint8_t CRCLo = 0xFF; 
    uint8_t CRCHi = 0xFF; 
    uint8_t uIndex;  
    uIndex = 0;

    while (MsgLen--)  
    { 
        uIndex = CRCLo ^ *Msg++; 
        CRCLo  = CRCHi ^ auchCRCLo[uIndex]; 
        CRCHi  = auchCRCHi[uIndex]; 
    } 

    return (CRCHi << 8) | CRCLo;
}

/**@brief       发送 Modbus RTU 消息包
* @param[in]    ModBusBaseParam : ModBus处理的基本参数结构体;
* @param[in]    pMsg : 消息包缓存; 
* @param[in]    len : 消息包长度;
* @param[in]    Check_Addr : 是否检查设备地址有效
* @return       函数执行结果
* - None
* @note         消息长度不能为0，发送时先解冻设备
*/
void MODBUS_RTU_SendData(ModBusBaseParam_TypeDef *ModBusBaseParam, uint8_t *pMsg, uint16_t len, uint8_t Check_Addr)
{
    uint8_t ucCRC[2];
    uint16_t uiCRC;
    //无效地址或者数据长度超限
    if(((uint8_t *)0 == pMsg) || (0 == len) || ((SEND_SIZE - 2) < len))
    {
        return;
    }
    //广播地址
    if((BROADCASTADDR == pMsg[0]) && Check_Addr)
    {
        return;
    }
    //设备被冻结
    if(FREEZE_DISABLE != ModBusBaseParam->Freeze)
    {
        return;
    }
    //得到CRC码
    uiCRC = MDB_Get_CRC16(pMsg, len);
    //CRC低字节在前
    ucCRC[0] = (uint8_t)uiCRC;     
    //CRC高字节在后
    ucCRC[1] = (uint8_t)(uiCRC >> 8);     

    pMsg[len] = ucCRC[0];
    pMsg[len + 1] = ucCRC[1];

    //开启发送
    Send_Data(ModBusBaseParam, pMsg, len + 2);
}

/**@brief       获取 Modbus RTU 消息包
* @param[in]    cyRecvBuff : 消息包缓存; 
* @param[in]    pCyLen : 输出的消息包长度(无错误则不包括CRC);
* @return       函数执行结果
* - ERR_INVALID_DATA : 无效数据
* - ERR_CRC : CRC校验错误
* - ERR_NONE : 无错误
*/
uint8_t MODBUS_RTU_RecvData(uint8_t* cyRecvBuff, uint16_t *pCyLen)
{
    uint16_t crc;
        
    //获取一帧ModBus RTU数据
    *pCyLen = Sensor_USART_GetReceData(cyRecvBuff);   
    if(*pCyLen < 2)         //接收的数据长度至少 >= 2
    {
        return ERR_INVALID_DATA;
    }
    //获取CRC值
    crc = cyRecvBuff[*pCyLen - 1] << 8;
    crc |= cyRecvBuff[*pCyLen - 2];
    //校验是否错误
    if( crc != MDB_Get_CRC16(cyRecvBuff, *pCyLen - 2) )
        return ERR_CRC;
    
    *pCyLen -= 2;
    
    return ERR_NONE;
}

#endif // defined(USING_MODBUS_RTU)
