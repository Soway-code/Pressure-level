# Keil uVision project Cap_Sensor.uvprojx, settings and files
target Cap_Sensor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Cap_Sensor
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\Cap_Sensor\Cap_Sensor.bin .\Cap_Sensor\Cap_Sensor.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\BSP\Inc;..\APP\Inc;..\ModBus\Inc
  memory RVCT4: ROM 0x8003000 size 0x1d000
  memory RVCT9: RAM 0x200000c0 size 0x3f40
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group APP
    ../APP/Src/: adc_app.c usart_app.c Picocap_app.c TypeConvert.c In_Memory_app.c
  group BSP
    ../BSP/Src/: In_Flash.c Picocap.c spi_bsp.c adc_bsp.c dac_bsp.c iwdg_bsp.c usart_bsp.c
  group ModBus
    ../ModBus/Src/: ModBus.c ModBus_ASCII.c ModBus_Conf.c ModBus_RTU.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
