# Keil uVision project STM32F072_BOOT.uvprojx, settings and files
target STM32F072_BOOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072_BOOT
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\STM32F072_BOOT\STM32F072_BOOT.bin .\STM32F072_BOOT\STM32F072_BOOT.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\APP\Inc;..\BSP\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group APP
    ../APP/Src/: common.c flash_if.c menu_uart.c modbus_ascii.c usart_app.c
  group BSP
    ../BSP/Src/: In_Flash.c usart_bsp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
